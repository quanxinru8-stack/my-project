# Keil uVision project Firmware_F405.uvprojx, settings and files
target Firmware405 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware_F405 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --diag_suppress=767,188,177
  c include: ..\lib\CMSIS\CoreSupport\Include;..\lib\CMSIS\DeviceSupport\ST\STM32F4xx\Include;..\lib\FreeRTOS\include;..\lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\lib\STM32_USB-Host-Device_Lib_V2.2.0\STM32_USB_OTG_Driver\inc;..\lib\STM32_USB-Host-Device_Lib_V2.2.0\STM32_USB_Device_Library\Core\inc;..\lib\STM32_USB-Host-Device_Lib_V2.2.0\STM32_USB_Device_Library\Class\cdc\inc;..\src\common\interface;..\src\communicate\interface;..\src\config\interface;..\src\main;..\src\sensors\interface;..\src\system\delay;..\src\system\sys;..\src\system\usart;..\src\usb_vcp\interface;..\src\navigation;..\src\fc\interface;..\src\flight\interface;..\src\drivers\interface;..\src\sd_fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../src/main/: main.c system_stm32f4xx.c
  group config
    ../src/config/src/: config_param.c
    ../src/config/interface/: config.h
  group fc
    ../src/fc/src/: commander.c pm.c rc_controls.c runtime_config.c rx.c ledstrip.c
  group communicate
    ../src/communicate/src/: atkp.c console.c usblink.c
  group sensors
    ../src/sensors/src/: accelerometer.c barometer.c compass.c gyro.c sensorsalignment.c
  group common
    ../src/common/src/: debug_assert.c filter.c freeRTOSdebug.c maths.c
  group system
    ../src/system/delay/: delay.c
    ../src/system/sys/: sys.c
    ../src/system/usart/: usart.c
  group startup
    ../lib/CMSIS/DeviceSupport/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group usb_vcp
    ../src/usb_vcp/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32_USB-Host-Device_Lib
    ../lib/STM32_USB-Host-Device_Lib_V2.2.0/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../lib/STM32_USB-Host-Device_Lib_V2.2.0/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../lib/STM32_USB-Host-Device_Lib_V2.2.0/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group FreeRTOS
    ../lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../lib/FreeRTOS/: list.c queue.c tasks.c timers.c
  group readme
    ../: readme.txt
  group drivers
    ../src/drivers/src/: adc1.c beeper.c bmp280.c cppm.c exti.c hmc5883l.c i2c_drv.c i2cdev.c led.c motors.c mpu6000.c nvic.c spi1.c stepmotor.c stmflash.c system.c watchdog.c ws2812.c uart5.c uart1.c
  group flight
    ../src/flight/src/: imu.c pid.c pos_estimator.c power_control.c sensors.c stabilizer.c state_control.c
  group sd_fatfs
    ../src/sd_fatfs/: MMC_SD.c ff.c diskio.c cc936.c BSP_SPI.C
